FILESEXTRAPATHS_prepend := "${THISDIR}/../:"

IMAGE_INSTALL_append = "dma-proxy dma-proxy-lib dma-proxy-utils gr-zynq"  
