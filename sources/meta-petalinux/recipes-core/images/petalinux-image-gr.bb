DESCRIPTION = "OSL image definition for Xilinx boards"
LICENSE = "MIT"

require petalinux-image-common.inc
require native-sdk.inc
require gnuradio-image.bb

IMAGE_FSTYPES = "tar.gz cpio.gz.u-boot"
