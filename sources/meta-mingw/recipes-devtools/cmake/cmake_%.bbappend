DEPENDS_remove_mingw32 = "ncurses"
RDEPENDS_${PN}-bash-completion_remove_mingw32 = "bash-completion"
