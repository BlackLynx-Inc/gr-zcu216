RDEPENDS_${PN}_mingw32 = "\
    nativesdk-sdk-provides-dummy \
    nativesdk-pkgconfig \
    nativesdk-libtool \
    nativesdk-qemu \
    nativesdk-make \
    "
